$ Spice netlist generated by v2lvs
$ v2013.3_28.19    Tue Sep 3 16:44:15 PDT 2013

.SUBCKT c1355 G1 G10 G11 G12 G13 G1324 G1325 G1326 G1327 G1328 G1329 G1330
+ G1331 G1332 G1333 G1334 G1335 G1336 G1337 G1338 G1339 G1340 G1341 G1342 G1343
+ G1344 G1345 G1346 G1347 G1348 G1349 G1350 G1351 G1352 G1353 G1354 G1355 G14
+ G15 G16 G17 G18 G19 G2 G20 G21 G22 G23 G24 G25 G26 G27 G28 G29 G3 G30 G31 G32
+ G33 G34 G35 G36 G37 G38 G39 G4 G40 G41 G5 G6 G7 G8 G9
XAND2_0 G242 G33 G41 and
XAND2_1 G245 G34 G41 and
XAND2_2 G248 G35 G41 and
XAND2_3 G251 G36 G41 and
XAND2_4 G254 G37 G41 and
XAND2_5 G257 G38 G41 and
XAND2_6 G260 G39 G41 and
XAND2_7 G263 G40 G41 and
XAND4_0 G978 G938 G939 G940 G873 and
XAND4_1 G979 G941 G942 G860 G943 and
XAND4_2 G980 G944 G847 G945 G946 and
XAND4_3 G981 G834 G947 G948 G949 and
XAND4_4 G982 G958 G959 G960 G899 and
XAND4_5 G983 G961 G962 G912 G963 and
XAND4_6 G984 G964 G886 G965 G966 and
XAND4_7 G985 G925 G967 G968 G969 and
XAND5_0 G996 G925 G950 G912 G951 G986 and
XAND5_1 G1001 G925 G952 G953 G899 G986 and
XAND5_2 G1006 G954 G886 G912 G955 G986 and
XAND5_3 G1011 G956 G886 G957 G899 G986 and
XAND5_4 G1016 G834 G970 G860 G971 G991 and
XAND5_5 G1021 G834 G972 G973 G873 G991 and
XAND5_6 G1026 G974 G847 G860 G975 G991 and
XAND5_7 G1031 G976 G847 G977 G873 G991 and
XAND2_8 G1036 G834 G996 and
XAND2_9 G1039 G847 G996 and
XAND2_10 G1042 G860 G996 and
XAND2_11 G1045 G873 G996 and
XAND2_12 G1048 G834 G1001 and
XAND2_13 G1051 G847 G1001 and
XAND2_14 G1054 G860 G1001 and
XAND2_15 G1057 G873 G1001 and
XAND2_16 G1060 G834 G1006 and
XAND2_17 G1063 G847 G1006 and
XAND2_18 G1066 G860 G1006 and
XAND2_19 G1069 G873 G1006 and
XAND2_20 G1072 G834 G1011 and
XAND2_21 G1075 G847 G1011 and
XAND2_22 G1078 G860 G1011 and
XAND2_23 G1081 G873 G1011 and
XAND2_24 G1084 G925 G1016 and
XAND2_25 G1087 G886 G1016 and
XAND2_26 G1090 G912 G1016 and
XAND2_27 G1093 G899 G1016 and
XAND2_28 G1096 G925 G1021 and
XAND2_29 G1099 G886 G1021 and
XAND2_30 G1102 G912 G1021 and
XAND2_31 G1105 G899 G1021 and
XAND2_32 G1108 G925 G1026 and
XAND2_33 G1111 G886 G1026 and
XAND2_34 G1114 G912 G1026 and
XAND2_35 G1117 G899 G1026 and
XAND2_36 G1120 G925 G1031 and
XAND2_37 G1123 G886 G1031 and
XAND2_38 G1126 G912 G1031 and
XAND2_39 G1129 G899 G1031 and
XNAND2_0 G266 G1 G2 nand
XNAND2_1 G269 G3 G4 nand
XNAND2_2 G272 G5 G6 nand
XNAND2_3 G275 G7 G8 nand
XNAND2_4 G278 G9 G10 nand
XNAND2_5 G281 G11 G12 nand
XNAND2_6 G284 G13 G14 nand
XNAND2_7 G287 G15 G16 nand
XNAND2_8 G290 G17 G18 nand
XNAND2_9 G293 G19 G20 nand
XNAND2_10 G296 G21 G22 nand
XNAND2_11 G299 G23 G24 nand
XNAND2_12 G302 G25 G26 nand
XNAND2_13 G305 G27 G28 nand
XNAND2_14 G308 G29 G30 nand
XNAND2_15 G311 G31 G32 nand
XNAND2_16 G314 G1 G5 nand
XNAND2_17 G317 G9 G13 nand
XNAND2_18 G320 G2 G6 nand
XNAND2_19 G323 G10 G14 nand
XNAND2_20 G326 G3 G7 nand
XNAND2_21 G329 G11 G15 nand
XNAND2_22 G332 G4 G8 nand
XNAND2_23 G335 G12 G16 nand
XNAND2_24 G338 G17 G21 nand
XNAND2_25 G341 G25 G29 nand
XNAND2_26 G344 G18 G22 nand
XNAND2_27 G347 G26 G30 nand
XNAND2_28 G350 G19 G23 nand
XNAND2_29 G353 G27 G31 nand
XNAND2_30 G356 G20 G24 nand
XNAND2_31 G359 G28 G32 nand
XNAND2_32 G362 G1 G266 nand
XNAND2_33 G363 G2 G266 nand
XNAND2_34 G364 G3 G269 nand
XNAND2_35 G365 G4 G269 nand
XNAND2_36 G366 G5 G272 nand
XNAND2_37 G367 G6 G272 nand
XNAND2_38 G368 G7 G275 nand
XNAND2_39 G369 G8 G275 nand
XNAND2_40 G370 G9 G278 nand
XNAND2_41 G371 G10 G278 nand
XNAND2_42 G372 G11 G281 nand
XNAND2_43 G373 G12 G281 nand
XNAND2_44 G374 G13 G284 nand
XNAND2_45 G375 G14 G284 nand
XNAND2_46 G376 G15 G287 nand
XNAND2_47 G377 G16 G287 nand
XNAND2_48 G378 G17 G290 nand
XNAND2_49 G379 G18 G290 nand
XNAND2_50 G380 G19 G293 nand
XNAND2_51 G381 G20 G293 nand
XNAND2_52 G382 G21 G296 nand
XNAND2_53 G383 G22 G296 nand
XNAND2_54 G384 G23 G299 nand
XNAND2_55 G385 G24 G299 nand
XNAND2_56 G386 G25 G302 nand
XNAND2_57 G387 G26 G302 nand
XNAND2_58 G388 G27 G305 nand
XNAND2_59 G389 G28 G305 nand
XNAND2_60 G390 G29 G308 nand
XNAND2_61 G391 G30 G308 nand
XNAND2_62 G392 G31 G311 nand
XNAND2_63 G393 G32 G311 nand
XNAND2_64 G394 G1 G314 nand
XNAND2_65 G395 G5 G314 nand
XNAND2_66 G396 G9 G317 nand
XNAND2_67 G397 G13 G317 nand
XNAND2_68 G398 G2 G320 nand
XNAND2_69 G399 G6 G320 nand
XNAND2_70 G400 G10 G323 nand
XNAND2_71 G401 G14 G323 nand
XNAND2_72 G402 G3 G326 nand
XNAND2_73 G403 G7 G326 nand
XNAND2_74 G404 G11 G329 nand
XNAND2_75 G405 G15 G329 nand
XNAND2_76 G406 G4 G332 nand
XNAND2_77 G407 G8 G332 nand
XNAND2_78 G408 G12 G335 nand
XNAND2_79 G409 G16 G335 nand
XNAND2_80 G410 G17 G338 nand
XNAND2_81 G411 G21 G338 nand
XNAND2_82 G412 G25 G341 nand
XNAND2_83 G413 G29 G341 nand
XNAND2_84 G414 G18 G344 nand
XNAND2_85 G415 G22 G344 nand
XNAND2_86 G416 G26 G347 nand
XNAND2_87 G417 G30 G347 nand
XNAND2_88 G418 G19 G350 nand
XNAND2_89 G419 G23 G350 nand
XNAND2_90 G420 G27 G353 nand
XNAND2_91 G421 G31 G353 nand
XNAND2_92 G422 G20 G356 nand
XNAND2_93 G423 G24 G356 nand
XNAND2_94 G424 G28 G359 nand
XNAND2_95 G425 G32 G359 nand
XNAND2_96 G426 G362 G363 nand
XNAND2_97 G429 G364 G365 nand
XNAND2_98 G432 G366 G367 nand
XNAND2_99 G435 G368 G369 nand
XNAND2_100 G438 G370 G371 nand
XNAND2_101 G441 G372 G373 nand
XNAND2_102 G444 G374 G375 nand
XNAND2_103 G447 G376 G377 nand
XNAND2_104 G450 G378 G379 nand
XNAND2_105 G453 G380 G381 nand
XNAND2_106 G456 G382 G383 nand
XNAND2_107 G459 G384 G385 nand
XNAND2_108 G462 G386 G387 nand
XNAND2_109 G465 G388 G389 nand
XNAND2_110 G468 G390 G391 nand
XNAND2_111 G471 G392 G393 nand
XNAND2_112 G474 G394 G395 nand
XNAND2_113 G477 G396 G397 nand
XNAND2_114 G480 G398 G399 nand
XNAND2_115 G483 G400 G401 nand
XNAND2_116 G486 G402 G403 nand
XNAND2_117 G489 G404 G405 nand
XNAND2_118 G492 G406 G407 nand
XNAND2_119 G495 G408 G409 nand
XNAND2_120 G498 G410 G411 nand
XNAND2_121 G501 G412 G413 nand
XNAND2_122 G504 G414 G415 nand
XNAND2_123 G507 G416 G417 nand
XNAND2_124 G510 G418 G419 nand
XNAND2_125 G513 G420 G421 nand
XNAND2_126 G516 G422 G423 nand
XNAND2_127 G519 G424 G425 nand
XNAND2_128 G522 G426 G429 nand
XNAND2_129 G525 G432 G435 nand
XNAND2_130 G528 G438 G441 nand
XNAND2_131 G531 G444 G447 nand
XNAND2_132 G534 G450 G453 nand
XNAND2_133 G537 G456 G459 nand
XNAND2_134 G540 G462 G465 nand
XNAND2_135 G543 G468 G471 nand
XNAND2_136 G546 G474 G477 nand
XNAND2_137 G549 G480 G483 nand
XNAND2_138 G552 G486 G489 nand
XNAND2_139 G555 G492 G495 nand
XNAND2_140 G558 G498 G501 nand
XNAND2_141 G561 G504 G507 nand
XNAND2_142 G564 G510 G513 nand
XNAND2_143 G567 G516 G519 nand
XNAND2_144 G570 G426 G522 nand
XNAND2_145 G571 G429 G522 nand
XNAND2_146 G572 G432 G525 nand
XNAND2_147 G573 G435 G525 nand
XNAND2_148 G574 G438 G528 nand
XNAND2_149 G575 G441 G528 nand
XNAND2_150 G576 G444 G531 nand
XNAND2_151 G577 G447 G531 nand
XNAND2_152 G578 G450 G534 nand
XNAND2_153 G579 G453 G534 nand
XNAND2_154 G580 G456 G537 nand
XNAND2_155 G581 G459 G537 nand
XNAND2_156 G582 G462 G540 nand
XNAND2_157 G583 G465 G540 nand
XNAND2_158 G584 G468 G543 nand
XNAND2_159 G585 G471 G543 nand
XNAND2_160 G586 G474 G546 nand
XNAND2_161 G587 G477 G546 nand
XNAND2_162 G588 G480 G549 nand
XNAND2_163 G589 G483 G549 nand
XNAND2_164 G590 G486 G552 nand
XNAND2_165 G591 G489 G552 nand
XNAND2_166 G592 G492 G555 nand
XNAND2_167 G593 G495 G555 nand
XNAND2_168 G594 G498 G558 nand
XNAND2_169 G595 G501 G558 nand
XNAND2_170 G596 G504 G561 nand
XNAND2_171 G597 G507 G561 nand
XNAND2_172 G598 G510 G564 nand
XNAND2_173 G599 G513 G564 nand
XNAND2_174 G600 G516 G567 nand
XNAND2_175 G601 G519 G567 nand
XNAND2_176 G602 G570 G571 nand
XNAND2_177 G607 G572 G573 nand
XNAND2_178 G612 G574 G575 nand
XNAND2_179 G617 G576 G577 nand
XNAND2_180 G622 G578 G579 nand
XNAND2_181 G627 G580 G581 nand
XNAND2_182 G632 G582 G583 nand
XNAND2_183 G637 G584 G585 nand
XNAND2_184 G642 G586 G587 nand
XNAND2_185 G645 G588 G589 nand
XNAND2_186 G648 G590 G591 nand
XNAND2_187 G651 G592 G593 nand
XNAND2_188 G654 G594 G595 nand
XNAND2_189 G657 G596 G597 nand
XNAND2_190 G660 G598 G599 nand
XNAND2_191 G663 G600 G601 nand
XNAND2_192 G666 G602 G607 nand
XNAND2_193 G669 G612 G617 nand
XNAND2_194 G672 G602 G612 nand
XNAND2_195 G675 G607 G617 nand
XNAND2_196 G678 G622 G627 nand
XNAND2_197 G681 G632 G637 nand
XNAND2_198 G684 G622 G632 nand
XNAND2_199 G687 G627 G637 nand
XNAND2_200 G690 G602 G666 nand
XNAND2_201 G691 G607 G666 nand
XNAND2_202 G692 G612 G669 nand
XNAND2_203 G693 G617 G669 nand
XNAND2_204 G694 G602 G672 nand
XNAND2_205 G695 G612 G672 nand
XNAND2_206 G696 G607 G675 nand
XNAND2_207 G697 G617 G675 nand
XNAND2_208 G698 G622 G678 nand
XNAND2_209 G699 G627 G678 nand
XNAND2_210 G700 G632 G681 nand
XNAND2_211 G701 G637 G681 nand
XNAND2_212 G702 G622 G684 nand
XNAND2_213 G703 G632 G684 nand
XNAND2_214 G704 G627 G687 nand
XNAND2_215 G705 G637 G687 nand
XNAND2_216 G706 G690 G691 nand
XNAND2_217 G709 G692 G693 nand
XNAND2_218 G712 G694 G695 nand
XNAND2_219 G715 G696 G697 nand
XNAND2_220 G718 G698 G699 nand
XNAND2_221 G721 G700 G701 nand
XNAND2_222 G724 G702 G703 nand
XNAND2_223 G727 G704 G705 nand
XNAND2_224 G730 G242 G718 nand
XNAND2_225 G733 G245 G721 nand
XNAND2_226 G736 G248 G724 nand
XNAND2_227 G739 G251 G727 nand
XNAND2_228 G742 G254 G706 nand
XNAND2_229 G745 G257 G709 nand
XNAND2_230 G748 G260 G712 nand
XNAND2_231 G751 G263 G715 nand
XNAND2_232 G754 G242 G730 nand
XNAND2_233 G755 G718 G730 nand
XNAND2_234 G756 G245 G733 nand
XNAND2_235 G757 G721 G733 nand
XNAND2_236 G758 G248 G736 nand
XNAND2_237 G759 G724 G736 nand
XNAND2_238 G760 G251 G739 nand
XNAND2_239 G761 G727 G739 nand
XNAND2_240 G762 G254 G742 nand
XNAND2_241 G763 G706 G742 nand
XNAND2_242 G764 G257 G745 nand
XNAND2_243 G765 G709 G745 nand
XNAND2_244 G766 G260 G748 nand
XNAND2_245 G767 G712 G748 nand
XNAND2_246 G768 G263 G751 nand
XNAND2_247 G769 G715 G751 nand
XNAND2_248 G770 G754 G755 nand
XNAND2_249 G773 G756 G757 nand
XNAND2_250 G776 G758 G759 nand
XNAND2_251 G779 G760 G761 nand
XNAND2_252 G782 G762 G763 nand
XNAND2_253 G785 G764 G765 nand
XNAND2_254 G788 G766 G767 nand
XNAND2_255 G791 G768 G769 nand
XNAND2_256 G794 G642 G770 nand
XNAND2_257 G797 G645 G773 nand
XNAND2_258 G800 G648 G776 nand
XNAND2_259 G803 G651 G779 nand
XNAND2_260 G806 G654 G782 nand
XNAND2_261 G809 G657 G785 nand
XNAND2_262 G812 G660 G788 nand
XNAND2_263 G815 G663 G791 nand
XNAND2_264 G818 G642 G794 nand
XNAND2_265 G819 G770 G794 nand
XNAND2_266 G820 G645 G797 nand
XNAND2_267 G821 G773 G797 nand
XNAND2_268 G822 G648 G800 nand
XNAND2_269 G823 G776 G800 nand
XNAND2_270 G824 G651 G803 nand
XNAND2_271 G825 G779 G803 nand
XNAND2_272 G826 G654 G806 nand
XNAND2_273 G827 G782 G806 nand
XNAND2_274 G828 G657 G809 nand
XNAND2_275 G829 G785 G809 nand
XNAND2_276 G830 G660 G812 nand
XNAND2_277 G831 G788 G812 nand
XNAND2_278 G832 G663 G815 nand
XNAND2_279 G833 G791 G815 nand
XNAND2_280 G834 G818 G819 nand
XNAND2_281 G847 G820 G821 nand
XNAND2_282 G860 G822 G823 nand
XNAND2_283 G873 G824 G825 nand
XNAND2_284 G886 G828 G829 nand
XNAND2_285 G899 G832 G833 nand
XNAND2_286 G912 G830 G831 nand
XNAND2_287 G925 G826 G827 nand
XNAND2_288 G1132 G1 G1036 nand
XNAND2_289 G1135 G2 G1039 nand
XNAND2_290 G1138 G3 G1042 nand
XNAND2_291 G1141 G4 G1045 nand
XNAND2_292 G1144 G5 G1048 nand
XNAND2_293 G1147 G6 G1051 nand
XNAND2_294 G1150 G7 G1054 nand
XNAND2_295 G1153 G8 G1057 nand
XNAND2_296 G1156 G9 G1060 nand
XNAND2_297 G1159 G10 G1063 nand
XNAND2_298 G1162 G11 G1066 nand
XNAND2_299 G1165 G12 G1069 nand
XNAND2_300 G1168 G13 G1072 nand
XNAND2_301 G1171 G14 G1075 nand
XNAND2_302 G1174 G15 G1078 nand
XNAND2_303 G1177 G16 G1081 nand
XNAND2_304 G1180 G17 G1084 nand
XNAND2_305 G1183 G18 G1087 nand
XNAND2_306 G1186 G19 G1090 nand
XNAND2_307 G1189 G20 G1093 nand
XNAND2_308 G1192 G21 G1096 nand
XNAND2_309 G1195 G22 G1099 nand
XNAND2_310 G1198 G23 G1102 nand
XNAND2_311 G1201 G24 G1105 nand
XNAND2_312 G1204 G25 G1108 nand
XNAND2_313 G1207 G26 G1111 nand
XNAND2_314 G1210 G27 G1114 nand
XNAND2_315 G1213 G28 G1117 nand
XNAND2_316 G1216 G29 G1120 nand
XNAND2_317 G1219 G30 G1123 nand
XNAND2_318 G1222 G31 G1126 nand
XNAND2_319 G1225 G32 G1129 nand
XNAND2_320 G1228 G1 G1132 nand
XNAND2_321 G1229 G1036 G1132 nand
XNAND2_322 G1230 G2 G1135 nand
XNAND2_323 G1231 G1039 G1135 nand
XNAND2_324 G1232 G3 G1138 nand
XNAND2_325 G1233 G1042 G1138 nand
XNAND2_326 G1234 G4 G1141 nand
XNAND2_327 G1235 G1045 G1141 nand
XNAND2_328 G1236 G5 G1144 nand
XNAND2_329 G1237 G1048 G1144 nand
XNAND2_330 G1238 G6 G1147 nand
XNAND2_331 G1239 G1051 G1147 nand
XNAND2_332 G1240 G7 G1150 nand
XNAND2_333 G1241 G1054 G1150 nand
XNAND2_334 G1242 G8 G1153 nand
XNAND2_335 G1243 G1057 G1153 nand
XNAND2_336 G1244 G9 G1156 nand
XNAND2_337 G1245 G1060 G1156 nand
XNAND2_338 G1246 G10 G1159 nand
XNAND2_339 G1247 G1063 G1159 nand
XNAND2_340 G1248 G11 G1162 nand
XNAND2_341 G1249 G1066 G1162 nand
XNAND2_342 G1250 G12 G1165 nand
XNAND2_343 G1251 G1069 G1165 nand
XNAND2_344 G1252 G13 G1168 nand
XNAND2_345 G1253 G1072 G1168 nand
XNAND2_346 G1254 G14 G1171 nand
XNAND2_347 G1255 G1075 G1171 nand
XNAND2_348 G1256 G15 G1174 nand
XNAND2_349 G1257 G1078 G1174 nand
XNAND2_350 G1258 G16 G1177 nand
XNAND2_351 G1259 G1081 G1177 nand
XNAND2_352 G1260 G17 G1180 nand
XNAND2_353 G1261 G1084 G1180 nand
XNAND2_354 G1262 G18 G1183 nand
XNAND2_355 G1263 G1087 G1183 nand
XNAND2_356 G1264 G19 G1186 nand
XNAND2_357 G1265 G1090 G1186 nand
XNAND2_358 G1266 G20 G1189 nand
XNAND2_359 G1267 G1093 G1189 nand
XNAND2_360 G1268 G21 G1192 nand
XNAND2_361 G1269 G1096 G1192 nand
XNAND2_362 G1270 G22 G1195 nand
XNAND2_363 G1271 G1099 G1195 nand
XNAND2_364 G1272 G23 G1198 nand
XNAND2_365 G1273 G1102 G1198 nand
XNAND2_366 G1274 G24 G1201 nand
XNAND2_367 G1275 G1105 G1201 nand
XNAND2_368 G1276 G25 G1204 nand
XNAND2_369 G1277 G1108 G1204 nand
XNAND2_370 G1278 G26 G1207 nand
XNAND2_371 G1279 G1111 G1207 nand
XNAND2_372 G1280 G27 G1210 nand
XNAND2_373 G1281 G1114 G1210 nand
XNAND2_374 G1282 G28 G1213 nand
XNAND2_375 G1283 G1117 G1213 nand
XNAND2_376 G1284 G29 G1216 nand
XNAND2_377 G1285 G1120 G1216 nand
XNAND2_378 G1286 G30 G1219 nand
XNAND2_379 G1287 G1123 G1219 nand
XNAND2_380 G1288 G31 G1222 nand
XNAND2_381 G1289 G1126 G1222 nand
XNAND2_382 G1290 G32 G1225 nand
XNAND2_383 G1291 G1129 G1225 nand
XNAND2_384 G1292 G1228 G1229 nand
XNAND2_385 G1293 G1230 G1231 nand
XNAND2_386 G1294 G1232 G1233 nand
XNAND2_387 G1295 G1234 G1235 nand
XNAND2_388 G1296 G1236 G1237 nand
XNAND2_389 G1297 G1238 G1239 nand
XNAND2_390 G1298 G1240 G1241 nand
XNAND2_391 G1299 G1242 G1243 nand
XNAND2_392 G1300 G1244 G1245 nand
XNAND2_393 G1301 G1246 G1247 nand
XNAND2_394 G1302 G1248 G1249 nand
XNAND2_395 G1303 G1250 G1251 nand
XNAND2_396 G1304 G1252 G1253 nand
XNAND2_397 G1305 G1254 G1255 nand
XNAND2_398 G1306 G1256 G1257 nand
XNAND2_399 G1307 G1258 G1259 nand
XNAND2_400 G1308 G1260 G1261 nand
XNAND2_401 G1309 G1262 G1263 nand
XNAND2_402 G1310 G1264 G1265 nand
XNAND2_403 G1311 G1266 G1267 nand
XNAND2_404 G1312 G1268 G1269 nand
XNAND2_405 G1313 G1270 G1271 nand
XNAND2_406 G1314 G1272 G1273 nand
XNAND2_407 G1315 G1274 G1275 nand
XNAND2_408 G1316 G1276 G1277 nand
XNAND2_409 G1317 G1278 G1279 nand
XNAND2_410 G1318 G1280 G1281 nand
XNAND2_411 G1319 G1282 G1283 nand
XNAND2_412 G1320 G1284 G1285 nand
XNAND2_413 G1321 G1286 G1287 nand
XNAND2_414 G1322 G1288 G1289 nand
XNAND2_415 G1323 G1290 G1291 nand
XOR4_0 G986 G978 G979 G980 G981 or
XOR4_1 G991 G982 G983 G984 G985 or
XNOT1_0 G938 G834 not
XNOT1_1 G939 G847 not
XNOT1_2 G940 G860 not
XNOT1_3 G941 G834 not
XNOT1_4 G942 G847 not
XNOT1_5 G943 G873 not
XNOT1_6 G944 G834 not
XNOT1_7 G945 G860 not
XNOT1_8 G946 G873 not
XNOT1_9 G947 G847 not
XNOT1_10 G948 G860 not
XNOT1_11 G949 G873 not
XNOT1_12 G950 G886 not
XNOT1_13 G951 G899 not
XNOT1_14 G952 G886 not
XNOT1_15 G953 G912 not
XNOT1_16 G954 G925 not
XNOT1_17 G955 G899 not
XNOT1_18 G956 G925 not
XNOT1_19 G957 G912 not
XNOT1_20 G958 G925 not
XNOT1_21 G959 G886 not
XNOT1_22 G960 G912 not
XNOT1_23 G961 G925 not
XNOT1_24 G962 G886 not
XNOT1_25 G963 G899 not
XNOT1_26 G964 G925 not
XNOT1_27 G965 G912 not
XNOT1_28 G966 G899 not
XNOT1_29 G967 G886 not
XNOT1_30 G968 G912 not
XNOT1_31 G969 G899 not
XNOT1_32 G970 G847 not
XNOT1_33 G971 G873 not
XNOT1_34 G972 G847 not
XNOT1_35 G973 G860 not
XNOT1_36 G974 G834 not
XNOT1_37 G975 G873 not
XNOT1_38 G976 G834 not
XNOT1_39 G977 G860 not
XNOT1_40 G1324 G1292 not
XNOT1_41 G1325 G1293 not
XNOT1_42 G1326 G1294 not
XNOT1_43 G1327 G1295 not
XNOT1_44 G1328 G1296 not
XNOT1_45 G1329 G1297 not
XNOT1_46 G1330 G1298 not
XNOT1_47 G1331 G1299 not
XNOT1_48 G1332 G1300 not
XNOT1_49 G1333 G1301 not
XNOT1_50 G1334 G1302 not
XNOT1_51 G1335 G1303 not
XNOT1_52 G1336 G1304 not
XNOT1_53 G1337 G1305 not
XNOT1_54 G1338 G1306 not
XNOT1_55 G1339 G1307 not
XNOT1_56 G1340 G1308 not
XNOT1_57 G1341 G1309 not
XNOT1_58 G1342 G1310 not
XNOT1_59 G1343 G1311 not
XNOT1_60 G1344 G1312 not
XNOT1_61 G1345 G1313 not
XNOT1_62 G1346 G1314 not
XNOT1_63 G1347 G1315 not
XNOT1_64 G1348 G1316 not
XNOT1_65 G1349 G1317 not
XNOT1_66 G1350 G1318 not
XNOT1_67 G1351 G1319 not
XNOT1_68 G1352 G1320 not
XNOT1_69 G1353 G1321 not
XNOT1_70 G1354 G1322 not
XNOT1_71 G1355 G1323 not
.ENDS
