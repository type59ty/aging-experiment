$ Spice netlist generated by v2lvs
$ v2013.3_28.19    Tue Sep 3 16:44:15 PDT 2013

.SUBCKT c17 N1 N2 N3 N6 N7 N22 N23
XNAND2_1 N10 N1  N3  nand
XNAND2_2 N11 N3  N6  nand
XNAND2_3 N16 N2  N11 nand
XNAND2_4 N19 N11 N7  nand
XNAND2_5 N22 N10 N16 nand
XNAND2_6 N23 N16 N19 nand
.ENDS
