$ Spice netlist generated by v2lvs
$ v2013.3_28.19    Tue Sep 3 16:44:15 PDT 2013

.SUBCKT c174 P1_N1 P1_N2 P1_N3 P1_N6 P1_N7 P1_N22 P1_N23 P2_N1 P2_N2 P2_N3 P2_N6 P2_N7 P2_N22 P2_N23 P3_N1 P3_N2 P3_N3 P3_N6 P3_N7 P3_N22 P3_N23 P4_N1 P4_N2 P4_N3 P4_N6 P4_N7 P4_N22 P4_N23

XNAND2_1  P1_N10 P1_N1  P1_N3  nand
XNAND2_2  P1_N11 P1_N3  P1_N6  nand
XNAND2_3  P1_N16 P1_N2  P1_N11 nand
XNAND2_4  P1_N19 P1_N11 P1_N7  nand
XNAND2_5  P1_N22 P1_N10 P1_N16 nand
XNAND2_6  P1_N23 P1_N16 P1_N19 nand

XNAND2_7  P2_N10 P2_N1  P2_N3  nand
XNAND2_8  P2_N11 P2_N3  P2_N6  nand
XNAND2_9  P2_N16 P2_N2  P2_N11 nand
XNAND2_10 P2_N19 P2_N11 P2_N7  nand
XNAND2_11 P2_N22 P2_N10 P2_N16 nand
XNAND2_12 P2_N23 P2_N16 P2_N19 nand

XNAND2_13 P3_N10 P3_N1  P3_N3  nand
XNAND2_14 P3_N11 P3_N3  P3_N6  nand
XNAND2_15 P3_N16 P3_N2  P3_N11 nand
XNAND2_16 P3_N19 P3_N11 P3_N7  nand
XNAND2_17 P3_N22 P3_N10 P3_N16 nand
XNAND2_18 P3_N23 P3_N16 P3_N19 nand

XNAND2_19 P4_N10 P4_N1  P4_N3  nand
XNAND2_20 P4_N11 P4_N3  P4_N6  nand
XNAND2_21 P4_N16 P4_N2  P4_N11 nand
XNAND2_22 P4_N19 P4_N11 P4_N7  nand
XNAND2_23 P4_N22 P4_N10 P4_N16 nand
XNAND2_24 P4_N23 P4_N16 P4_N19 nand

.ENDS
