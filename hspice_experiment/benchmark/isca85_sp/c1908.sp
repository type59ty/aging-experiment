$ Spice netlist generated by v2lvs
$ v2013.3_28.19    Tue Sep 3 16:44:15 PDT 2013

.SUBCKT c1908 N1 N4 N7 N10 N13 N16 N19 N22 N25 N28 N31 N34 N37 N40 N43 N46 N49
+ N53 N56 N60 N63 N66 N69 N72 N76 N79 N82 N85 N88 N91 N94 N99 N104 N2753 N2754
+ N2755 N2756 N2762 N2767 N2768 N2779 N2780 N2781 N2782 N2783 N2784 N2785 N2786
+ N2787 N2811 N2886 N2887 N2888 N2889 N2890 N2891 N2892 N2899
XAND2_87 N574 N63 N319 and
XAND2_91 N586 N66 N319 and
XAND3_93 N592 N49 N253 N319 and
XAND3_110 N643 N56 N257 N319 and
XAND3_114 N655 N60 N257 N319 and
XAND2_123 N682 N251 N316 and
XAND2_124 N685 N252 N316 and
XAND3_137 N724 N53 N253 N319 and
XAND2_158 N897 N49 N612 and
XAND2_159 N898 N56 N608 and
XAND3_175 N926 N303 N338 N603 and
XAND2_594 N1965 N1910 N601 and
XAND2_595 N1968 N602 N1912 and
XAND2_653 N2104 N2030 N2068 and
XAND2_654 N2119 N2033 N2068 and
XAND2_655 N2129 N2030 N2071 and
XAND2_656 N2143 N2033 N2071 and
XAND2_693 N2266 N1164 N2241 and
XAND2_695 N2272 N1168 N2245 and
XAND2_701 N2340 N2086 N2257 and
XAND2_702 N2353 N2089 N2257 and
XAND2_703 N2361 N2086 N2260 and
XAND2_704 N2375 N2089 N2260 and
XAND4_705 N2384 N338 N2279 N313 N313 and
XAND2_706 N2385 N1163 N2263 and
XAND2_707 N2386 N1164 N2263 and
XAND2_708 N2426 N1167 N2269 and
XAND2_709 N2427 N1168 N2269 and
XAND5_717 N2558 N2286 N2315 N2361 N2104 N1171 and
XAND5_718 N2561 N2286 N2315 N2340 N2129 N1171 and
XAND5_719 N2564 N2286 N2315 N2340 N2119 N1171 and
XAND5_720 N2567 N2286 N2315 N2353 N2104 N1171 and
XAND5_721 N2570 N2297 N2315 N2375 N2119 N1188 and
XAND5_722 N2573 N2297 N2326 N2361 N2143 N1188 and
XAND5_723 N2576 N2297 N2326 N2375 N2129 N1188 and
XAND5_741 N2639 N2286 N2427 N2361 N2129 N1171 and
XAND5_742 N2642 N2297 N2427 N2361 N2119 N1171 and
XAND5_743 N2645 N2297 N2427 N2375 N2104 N1171 and
XAND5_744 N2648 N2297 N2427 N2340 N2143 N1171 and
XAND5_745 N2651 N2297 N2427 N2353 N2129 N1188 and
XAND5_746 N2655 N2386 N2326 N2361 N2129 N1188 and
XAND5_747 N2658 N2386 N2326 N2361 N2119 N1188 and
XAND5_748 N2661 N2386 N2326 N2375 N2104 N1188 and
XAND5_749 N2664 N2386 N2326 N2353 N2129 N1188 and
XAND8_764 N2710 N2627 N2628 N2629 N2630 N2631 N2632 N2633 N2634 and
XAND8_792 N2747 N2537 N2540 N2543 N2546 N2594 N2597 N2600 N2603 and
XAND8_793 N2750 N2606 N2549 N2611 N2614 N2617 N2620 N2552 N2555 and
XAND2_810 N2773 N2745 N275 and
XAND2_811 N2776 N2746 N276 and
XAND3_821 N2788 N2747 N2750 N2710 and
XAND4_823 N2800 N338 N2279 N99 N2788 and
XAND3_829 N2812 N897 N283 N2789 and
XAND3_830 N2815 N76 N283 N2789 and
XAND3_831 N2818 N82 N283 N2789 and
XAND3_832 N2821 N85 N283 N2789 and
XAND3_833 N2824 N898 N283 N2789 and
XAND3_836 N2829 N79 N283 N2789 and
XAND2_869 N2886 N2876 N550 and
XAND2_870 N2887 N551 N2877 and
XAND2_871 N2888 N553 N2878 and
XAND2_872 N2889 N2879 N554 and
XAND2_873 N2890 N555 N2880 and
XAND2_880 N2899 N2898 N552 and
XNAND2_17 N251 N63 N88 nand
XNAND2_18 N252 N66 N91 nand
XNAND2_75 N550 N306 N331 nand
XNAND2_76 N551 N306 N331 nand
XNAND2_77 N552 N306 N331 nand
XNAND2_78 N553 N306 N331 nand
XNAND2_79 N554 N306 N331 nand
XNAND2_80 N555 N306 N331 nand
XNAND2_96 N601 N326 N277 nand
XNAND2_97 N602 N326 N280 nand
XNAND2_98 N603 N260 N72 nand
XNAND2_99 N608 N260 N300 nand
XNAND2_100 N612 N256 N300 nand
XNAND2_160 N899 N53 N612 nand
XNAND2_161 N903 N60 N608 nand
XNAND2_162 N907 N49 N612 nand
XNAND2_163 N910 N56 N608 nand
XNAND4_172 N921 N277 N297 N326 N603 nand
XNAND4_173 N922 N280 N297 N326 N603 nand
XNAND3_174 N923 N303 N338 N603 nand
XNAND2_233 N1054 N619 N888 nand
XNAND2_234 N1055 N616 N889 nand
XNAND2_235 N1063 N625 N890 nand
XNAND2_236 N1064 N622 N891 nand
XNAND2_237 N1067 N655 N895 nand
XNAND2_238 N1068 N652 N896 nand
XNAND2_239 N1119 N721 N988 nand
XNAND2_240 N1120 N718 N989 nand
XNAND2_241 N1121 N727 N991 nand
XNAND2_242 N1122 N724 N992 nand
XNAND2_243 N1128 N739 N1002 nand
XNAND2_244 N1129 N736 N1003 nand
XNAND2_245 N1130 N745 N1005 nand
XNAND2_246 N1131 N742 N1006 nand
XNAND2_247 N1132 N751 N1008 nand
XNAND2_248 N1133 N748 N1009 nand
XNAND2_251 N1150 N1054 N1055 nand
XNAND2_259 N1158 N1063 N1064 nand
XNAND2_261 N1160 N985 N892 nand
XNAND2_263 N1162 N1067 N1068 nand
XNAND2_268 N1171 N921 N923 nand
XNAND2_269 N1188 N922 N923 nand
XNAND2_271 N1206 N1010 N938 nand
XNAND2_273 N1208 N1013 N942 nand
XNAND2_275 N1210 N1016 N946 nand
XNAND2_277 N1212 N1019 N950 nand
XNAND2_279 N1214 N1022 N954 nand
XNAND2_281 N1216 N1025 N958 nand
XNAND2_286 N1221 N1034 N968 nand
XNAND2_289 N1224 N1037 N972 nand
XNAND2_291 N1226 N1040 N976 nand
XNAND2_294 N1229 N1043 N980 nand
XNAND2_296 N1231 N981 N984 nand
XNAND2_297 N1232 N1119 N1120 nand
XNAND2_298 N1235 N1121 N1122 nand
XNAND2_300 N1239 N1046 N997 nand
XNAND2_303 N1242 N1049 N1001 nand
XNAND2_304 N1243 N1128 N1129 nand
XNAND2_305 N1246 N1130 N1131 nand
XNAND2_306 N1249 N1132 N1133 nand
XNAND2_312 N1267 N631 N1159 nand
XNAND2_313 N1309 N688 N1205 nand
XNAND2_314 N1310 N691 N1207 nand
XNAND2_315 N1311 N694 N1209 nand
XNAND2_316 N1312 N697 N1211 nand
XNAND2_317 N1313 N700 N1213 nand
XNAND2_318 N1314 N703 N1215 nand
XNAND2_319 N1315 N706 N1220 nand
XNAND2_320 N1316 N709 N1223 nand
XNAND2_321 N1317 N712 N1225 nand
XNAND2_322 N1318 N715 N1228 nand
XNAND2_324 N1322 N628 N1230 nand
XNAND2_325 N1327 N730 N1238 nand
XNAND2_326 N1328 N733 N1241 nand
XNAND2_328 N1344 N1267 N1160 nand
XNAND2_329 N1345 N1249 N894 nand
XNAND2_335 N1352 N1309 N1206 nand
XNAND2_336 N1355 N1310 N1208 nand
XNAND2_337 N1358 N1311 N1210 nand
XNAND2_338 N1361 N1312 N1212 nand
XNAND2_339 N1364 N1313 N1214 nand
XNAND2_340 N1367 N1314 N1216 nand
XNAND2_341 N1370 N1315 N1221 nand
XNAND2_342 N1373 N1316 N1224 nand
XNAND2_343 N1376 N1317 N1226 nand
XNAND2_344 N1379 N1318 N1229 nand
XNAND2_345 N1383 N1322 N1231 nand
XNAND2_347 N1387 N1232 N990 nand
XNAND2_349 N1389 N1235 N993 nand
XNAND2_350 N1390 N1327 N1239 nand
XNAND2_351 N1393 N1328 N1242 nand
XNAND2_353 N1397 N1243 N1004 nand
XNAND2_355 N1399 N1246 N1007 nand
XNAND2_357 N1412 N649 N1346 nand
XNAND2_361 N1433 N634 N1386 nand
XNAND2_362 N1434 N637 N1388 nand
XNAND2_363 N1438 N640 N1396 nand
XNAND2_364 N1439 N646 N1398 nand
XNAND2_366 N1443 N1355 N1148 nand
XNAND2_368 N1445 N1352 N1149 nand
XNAND2_370 N1447 N1358 N1151 nand
XNAND2_372 N1451 N1361 N1152 nand
XNAND2_374 N1453 N1367 N1153 nand
XNAND2_376 N1455 N1364 N1154 nand
XNAND2_378 N1457 N1373 N1156 nand
XNAND2_380 N1459 N1379 N1157 nand
XNAND2_383 N1462 N1393 N1161 nand
XNAND2_385 N1464 N1345 N1412 nand
XNAND2_387 N1469 N1370 N1222 nand
XNAND2_389 N1471 N1376 N1227 nand
XNAND2_390 N1472 N1387 N1433 nand
XNAND2_392 N1476 N1390 N1240 nand
XNAND2_393 N1478 N1389 N1434 nand
XNAND2_394 N1481 N1399 N1439 nand
XNAND2_395 N1484 N1397 N1438 nand
XNAND2_396 N1487 N939 N1444 nand
XNAND2_397 N1488 N935 N1446 nand
XNAND2_398 N1489 N943 N1448 nand
XNAND2_401 N1492 N947 N1452 nand
XNAND2_402 N1493 N955 N1454 nand
XNAND2_403 N1494 N951 N1456 nand
XNAND2_404 N1495 N969 N1458 nand
XNAND2_405 N1496 N977 N1460 nand
XNAND2_406 N1498 N998 N1463 nand
XNAND2_408 N1500 N965 N1468 nand
XNAND2_409 N1501 N973 N1470 nand
XNAND2_410 N1504 N994 N1475 nand
XNAND2_412 N1513 N1443 N1487 nand
XNAND2_413 N1514 N1445 N1488 nand
XNAND2_414 N1517 N1447 N1489 nand
XNAND2_415 N1520 N1451 N1492 nand
XNAND2_416 N1521 N1453 N1493 nand
XNAND2_417 N1522 N1455 N1494 nand
XNAND2_418 N1526 N1457 N1495 nand
XNAND2_419 N1527 N1459 N1496 nand
XNAND2_421 N1529 N1462 N1498 nand
XNAND2_425 N1534 N1471 N1501 nand
XNAND2_426 N1537 N1469 N1500 nand
XNAND2_427 N1540 N1476 N1504 nand
XNAND2_432 N1567 N1484 N1531 nand
XNAND2_433 N1568 N1481 N1532 nand
XNAND2_440 N1594 N1540 N1530 nand
XNAND2_442 N1596 N1567 N1568 nand
XNAND2_452 N1636 N1478 N1595 nand
XNAND2_453 N1638 N1576 N1569 nand
XNAND2_462 N1671 N1596 N893 nand
XNAND2_466 N1678 N1606 N1217 nand
XNAND2_468 N1680 N1609 N1219 nand
XNAND2_472 N1685 N1594 N1636 nand
XNAND2_473 N1688 N1510 N1639 nand
XNAND2_476 N1706 N643 N1672 nand
XNAND2_478 N1708 N1647 N1675 nand
XNAND2_480 N1710 N1651 N1677 nand
XNAND2_482 N1712 N1028 N1679 nand
XNAND2_483 N1713 N1031 N1681 nand
XNAND2_486 N1720 N1658 N1593 nand
XNAND2_488 N1723 N1638 N1688 nand
XNAND2_494 N1740 N1685 N1528 nand
XNAND2_496 N1742 N1671 N1706 nand
XNAND2_497 N1746 N1600 N1709 nand
XNAND2_498 N1747 N1603 N1711 nand
XNAND2_499 N1748 N1678 N1712 nand
XNAND2_500 N1751 N1680 N1713 nand
XNAND2_501 N1759 N1537 N1721 nand
XNAND2_503 N1762 N1697 N1727 nand
XNAND2_505 N1764 N1701 N1730 nand
XNAND2_507 N1769 N1472 N1741 nand
XNAND2_508 N1772 N1723 N1413 nand
XNAND2_510 N1774 N1708 N1746 nand
XNAND2_511 N1777 N1710 N1747 nand
XNAND2_513 N1784 N1731 N1682 nand
XNAND2_516 N1787 N1734 N1683 nand
XNAND2_517 N1788 N1720 N1759 nand
XNAND2_518 N1791 N1661 N1761 nand
XNAND2_519 N1792 N1664 N1763 nand
XNAND2_520 N1795 N1751 N1155 nand
XNAND2_522 N1798 N1740 N1769 nand
XNAND2_523 N1801 N1334 N1773 nand
XNAND2_524 N1802 N1742 N290 nand
XNAND2_526 N1808 N1748 N1218 nand
XNAND2_527 N1809 N1612 N1783 nand
XNAND2_528 N1810 N1615 N1786 nand
XNAND2_529 N1812 N1791 N1762 nand
XNAND2_530 N1815 N1792 N1764 nand
XNAND2_532 N1821 N1777 N1490 nand
XNAND2_534 N1823 N1774 N1491 nand
XNAND2_536 N1825 N962 N1796 nand
XNAND2_537 N1826 N1788 N1409 nand
XNAND2_539 N1830 N1772 N1801 nand
XNAND2_540 N1837 N959 N1807 nand
XNAND2_541 N1838 N1809 N1784 nand
XNAND2_542 N1841 N1810 N1787 nand
XNAND2_543 N1848 N1419 N1822 nand
XNAND2_544 N1849 N1416 N1824 nand
XNAND2_545 N1850 N1795 N1825 nand
XNAND2_546 N1852 N1319 N1827 nand
XNAND2_547 N1855 N1815 N1707 nand
XNAND2_550 N1858 N1798 N290 nand
XNAND2_552 N1865 N1812 N1728 nand
XNAND2_556 N1875 N1808 N1837 nand
XNAND2_557 N1878 N1821 N1848 nand
XNAND2_558 N1879 N1823 N1849 nand
XNAND2_559 N1882 N1841 N1768 nand
XNAND2_561 N1884 N1826 N1852 nand
XNAND2_562 N1885 N1643 N1856 nand
XNAND2_563 N1889 N1830 N290 nand
XNAND2_565 N1896 N1838 N1785 nand
XNAND2_566 N1897 N1640 N1864 nand
XNAND2_570 N1911 N1717 N1883 nand
XNAND2_572 N1913 N1855 N1885 nand
XNAND2_574 N1919 N1872 N919 nand
XNAND2_576 N1921 N1869 N920 nand
XNAND2_579 N1924 N1714 N1895 nand
XNAND2_582 N1933 N1865 N1897 nand
XNAND2_583 N1936 N1882 N1911 nand
XNAND2_586 N1941 N679 N1920 nand
XNAND2_587 N1942 N676 N1922 nand
XNAND2_593 N1961 N1896 N1924 nand
XNAND2_596 N1975 N1930 N917 nand
XNAND2_598 N1977 N1927 N918 nand
XNAND2_600 N1979 N1919 N1941 nand
XNAND2_601 N1980 N1921 N1942 nand
XNAND2_605 N2000 N1944 N1937 nand
XNAND2_607 N2003 N1947 N1499 nand
XNAND2_608 N2004 N1953 N1350 nand
XNAND2_610 N2006 N1950 N1351 nand
XNAND2_612 N2008 N673 N1976 nand
XNAND2_613 N2009 N670 N1978 nand
XNAND2_616 N2014 N1958 N1923 nand
XNAND2_618 N2016 N1961 N1635 nand
XNAND2_621 N2020 N1898 N1999 nand
XNAND2_623 N2022 N1987 N1591 nand
XNAND2_624 N2023 N1440 N2002 nand
XNAND2_625 N2024 N1261 N2005 nand
XNAND2_626 N2025 N1258 N2007 nand
XNAND2_627 N2026 N1975 N2008 nand
XNAND2_628 N2027 N1977 N2009 nand
XNAND2_631 N2036 N1875 N2013 nand
XNAND2_632 N2037 N1571 N2015 nand
XNAND2_633 N2038 N2020 N2000 nand
XNAND2_634 N2039 N1534 N2021 nand
XNAND2_635 N2040 N2023 N2003 nand
XNAND2_636 N2041 N2004 N2024 nand
XNAND2_637 N2042 N2006 N2025 nand
XNAND2_639 N2052 N2036 N2014 nand
XNAND2_640 N2055 N2037 N2016 nand
XNAND2_642 N2061 N2039 N2022 nand
XNAND2_643 N2062 N2040 N290 nand
XNAND2_649 N2078 N2060 N290 nand
XNAND2_650 N2081 N2061 N290 nand
XNAND2_663 N2214 N2151 N915 nand
XNAND2_665 N2216 N2148 N916 nand
XNAND2_667 N2222 N2199 N1348 nand
XNAND2_669 N2224 N2196 N1349 nand
XNAND2_671 N2226 N2205 N913 nand
XNAND2_673 N2228 N2202 N914 nand
XNAND2_675 N2230 N667 N2215 nand
XNAND2_676 N2231 N664 N2217 nand
XNAND2_677 N2232 N1255 N2223 nand
XNAND2_678 N2233 N1252 N2225 nand
XNAND2_679 N2234 N661 N2227 nand
XNAND2_680 N2235 N658 N2229 nand
XNAND2_681 N2236 N2214 N2230 nand
XNAND2_682 N2237 N2216 N2231 nand
XNAND2_683 N2240 N2222 N2232 nand
XNAND2_684 N2241 N2224 N2233 nand
XNAND2_685 N2244 N2226 N2234 nand
XNAND2_686 N2245 N2228 N2235 nand
XNAND8_696 N2279 N2067 N2012 N2047 N2250 N899 N2256 N2253 N903 nand
XNAND5_710 N2537 N2286 N2315 N2361 N2104 N1171 nand
XNAND5_711 N2540 N2286 N2315 N2340 N2129 N1171 nand
XNAND5_712 N2543 N2286 N2315 N2340 N2119 N1171 nand
XNAND5_713 N2546 N2286 N2315 N2353 N2104 N1171 nand
XNAND5_714 N2549 N2297 N2315 N2375 N2119 N1188 nand
XNAND5_715 N2552 N2297 N2326 N2361 N2143 N1188 nand
XNAND5_716 N2555 N2297 N2326 N2375 N2129 N1188 nand
XNAND5_724 N2594 N2286 N2427 N2361 N2129 N1171 nand
XNAND5_725 N2597 N2297 N2427 N2361 N2119 N1171 nand
XNAND5_726 N2600 N2297 N2427 N2375 N2104 N1171 nand
XNAND5_727 N2603 N2297 N2427 N2340 N2143 N1171 nand
XNAND5_728 N2606 N2297 N2427 N2353 N2129 N1188 nand
XNAND5_729 N2611 N2386 N2326 N2361 N2129 N1188 nand
XNAND5_730 N2614 N2386 N2326 N2361 N2119 N1188 nand
XNAND5_731 N2617 N2386 N2326 N2375 N2104 N1188 nand
XNAND5_732 N2620 N2386 N2326 N2353 N2129 N1188 nand
XNAND5_733 N2627 N2297 N2427 N2340 N2104 N926 nand
XNAND5_734 N2628 N2386 N2326 N2340 N2104 N926 nand
XNAND5_735 N2629 N2386 N2427 N2361 N2104 N926 nand
XNAND5_736 N2630 N2386 N2427 N2340 N2129 N926 nand
XNAND5_737 N2631 N2386 N2427 N2340 N2119 N926 nand
XNAND5_738 N2632 N2386 N2427 N2353 N2104 N926 nand
XNAND5_739 N2633 N2386 N2426 N2340 N2104 N926 nand
XNAND5_740 N2634 N2385 N2427 N2340 N2104 N926 nand
XNAND2_750 N2669 N2558 N534 nand
XNAND2_752 N2671 N2561 N535 nand
XNAND2_754 N2673 N2564 N536 nand
XNAND2_756 N2675 N2567 N537 nand
XNAND2_758 N2682 N2570 N543 nand
XNAND2_760 N2688 N2573 N548 nand
XNAND2_762 N2690 N2576 N549 nand
XNAND2_765 N2720 N343 N2670 nand
XNAND2_766 N2721 N346 N2672 nand
XNAND2_767 N2722 N349 N2674 nand
XNAND2_768 N2723 N352 N2676 nand
XNAND2_769 N2724 N2639 N538 nand
XNAND2_771 N2726 N2642 N539 nand
XNAND2_773 N2728 N2645 N540 nand
XNAND2_775 N2730 N2648 N541 nand
XNAND2_777 N2732 N2651 N542 nand
XNAND2_779 N2734 N370 N2683 nand
XNAND2_780 N2735 N2655 N544 nand
XNAND2_782 N2737 N2658 N545 nand
XNAND2_784 N2739 N2661 N546 nand
XNAND2_786 N2741 N2664 N547 nand
XNAND2_788 N2743 N385 N2689 nand
XNAND2_789 N2744 N388 N2691 nand
XNAND8_790 N2745 N2537 N2540 N2543 N2546 N2594 N2597 N2600 N2603 nand
XNAND8_791 N2746 N2606 N2549 N2611 N2614 N2617 N2620 N2552 N2555 nand
XNAND2_794 N2753 N2669 N2720 nand
XNAND2_795 N2754 N2671 N2721 nand
XNAND2_796 N2755 N2673 N2722 nand
XNAND2_797 N2756 N2675 N2723 nand
XNAND2_798 N2757 N355 N2725 nand
XNAND2_799 N2758 N358 N2727 nand
XNAND2_800 N2759 N361 N2729 nand
XNAND2_801 N2760 N364 N2731 nand
XNAND2_802 N2761 N367 N2733 nand
XNAND2_803 N2762 N2682 N2734 nand
XNAND2_804 N2763 N373 N2736 nand
XNAND2_805 N2764 N376 N2738 nand
XNAND2_806 N2765 N379 N2740 nand
XNAND2_807 N2766 N382 N2742 nand
XNAND2_808 N2767 N2688 N2743 nand
XNAND2_809 N2768 N2690 N2744 nand
XNAND2_812 N2779 N2724 N2757 nand
XNAND2_813 N2780 N2726 N2758 nand
XNAND2_814 N2781 N2728 N2759 nand
XNAND2_815 N2782 N2730 N2760 nand
XNAND2_816 N2783 N2732 N2761 nand
XNAND2_817 N2784 N2735 N2763 nand
XNAND2_818 N2785 N2737 N2764 nand
XNAND2_819 N2786 N2739 N2765 nand
XNAND2_820 N2787 N2741 N2766 nand
XNAND2_822 N2789 N2747 N2750 nand
XNAND2_824 N2807 N2773 N2018 nand
XNAND2_826 N2809 N2776 N2019 nand
XNAND2_834 N2827 N1965 N2808 nand
XNAND2_835 N2828 N1968 N2810 nand
XNAND2_837 N2843 N2807 N2827 nand
XNAND2_838 N2846 N2809 N2828 nand
XNAND2_839 N2850 N2812 N2076 nand
XNAND2_840 N2851 N2815 N2077 nand
XNAND2_841 N2852 N2818 N1915 nand
XNAND2_842 N2853 N2821 N1857 nand
XNAND2_843 N2854 N2824 N1938 nand
XNAND2_850 N2863 N2829 N1985 nand
XNAND2_851 N2866 N2052 N2857 nand
XNAND2_852 N2867 N2055 N2858 nand
XNAND2_853 N2868 N1866 N2859 nand
XNAND2_854 N2869 N1818 N2860 nand
XNAND2_855 N2870 N1902 N2861 nand
XNAND2_856 N2871 N2843 N886 nand
XNAND2_858 N2873 N2846 N887 nand
XNAND2_860 N2875 N1933 N2862 nand
XNAND2_861 N2876 N2866 N2850 nand
XNAND2_862 N2877 N2867 N2851 nand
XNAND2_863 N2878 N2868 N2852 nand
XNAND2_864 N2879 N2869 N2853 nand
XNAND2_865 N2880 N2870 N2854 nand
XNAND2_866 N2881 N682 N2872 nand
XNAND2_867 N2882 N685 N2874 nand
XNAND2_868 N2883 N2875 N2863 nand
XNAND2_874 N2891 N2871 N2881 nand
XNAND2_875 N2892 N2873 N2882 nand
XNAND2_876 N2895 N2883 N1461 nand
XNAND2_878 N2897 N1383 N2896 nand
XNAND2_879 N2898 N2895 N2897 nand
XNOR2_828 N2811 N2384 N2800 nor
XBUFF1_21 N257 N69 buf
XBUFF1_22 N260 N69 buf
XBUFF1_31 N283 N94 buf
XBUFF1_33 N297 N94 buf
XBUFF1_35 N303 N99 buf
XBUFF1_38 N316 N104 buf
XBUFF1_40 N326 N104 buf
XBUFF1_41 N331 N104 buf
XBUFF1_43 N343 N1 buf
XBUFF1_44 N346 N4 buf
XBUFF1_45 N349 N7 buf
XBUFF1_46 N352 N10 buf
XBUFF1_47 N355 N13 buf
XBUFF1_48 N358 N16 buf
XBUFF1_49 N361 N19 buf
XBUFF1_50 N364 N22 buf
XBUFF1_51 N367 N25 buf
XBUFF1_52 N370 N28 buf
XBUFF1_53 N373 N31 buf
XBUFF1_54 N376 N34 buf
XBUFF1_55 N379 N37 buf
XBUFF1_56 N382 N40 buf
XBUFF1_57 N385 N43 buf
XBUFF1_58 N388 N46 buf
XBUFF1_81 N556 N190 buf
XBUFF1_82 N559 N194 buf
XBUFF1_83 N562 N206 buf
XBUFF1_84 N565 N209 buf
XBUFF1_85 N568 N225 buf
XBUFF1_86 N571 N243 buf
XBUFF1_88 N577 N220 buf
XBUFF1_89 N580 N229 buf
XBUFF1_90 N583 N232 buf
XBUFF1_92 N589 N239 buf
XBUFF1_94 N595 N247 buf
XBUFF1_95 N598 N239 buf
XBUFF1_101 N616 N201 buf
XBUFF1_102 N619 N216 buf
XBUFF1_103 N622 N220 buf
XBUFF1_104 N625 N239 buf
XBUFF1_105 N628 N190 buf
XBUFF1_106 N631 N190 buf
XBUFF1_107 N634 N194 buf
XBUFF1_108 N637 N229 buf
XBUFF1_109 N640 N197 buf
XBUFF1_111 N646 N232 buf
XBUFF1_112 N649 N201 buf
XBUFF1_113 N652 N235 buf
XBUFF1_115 N658 N263 buf
XBUFF1_116 N661 N263 buf
XBUFF1_117 N664 N266 buf
XBUFF1_118 N667 N266 buf
XBUFF1_119 N670 N269 buf
XBUFF1_120 N673 N269 buf
XBUFF1_121 N676 N272 buf
XBUFF1_122 N679 N272 buf
XBUFF1_125 N688 N197 buf
XBUFF1_126 N691 N197 buf
XBUFF1_127 N694 N212 buf
XBUFF1_128 N697 N212 buf
XBUFF1_129 N700 N247 buf
XBUFF1_130 N703 N247 buf
XBUFF1_131 N706 N235 buf
XBUFF1_132 N709 N235 buf
XBUFF1_133 N712 N201 buf
XBUFF1_134 N715 N201 buf
XBUFF1_135 N718 N206 buf
XBUFF1_136 N721 N216 buf
XBUFF1_138 N727 N243 buf
XBUFF1_139 N730 N220 buf
XBUFF1_140 N733 N220 buf
XBUFF1_141 N736 N209 buf
XBUFF1_142 N739 N216 buf
XBUFF1_143 N742 N225 buf
XBUFF1_144 N745 N243 buf
XBUFF1_145 N748 N212 buf
XBUFF1_146 N751 N225 buf
XBUFF1_176 N935 N556 buf
XBUFF1_178 N939 N556 buf
XBUFF1_180 N943 N562 buf
XBUFF1_182 N947 N562 buf
XBUFF1_184 N951 N568 buf
XBUFF1_186 N955 N568 buf
XBUFF1_188 N959 N574 buf
XBUFF1_189 N962 N574 buf
XBUFF1_190 N965 N580 buf
XBUFF1_192 N969 N580 buf
XBUFF1_194 N973 N586 buf
XBUFF1_196 N977 N586 buf
XBUFF1_198 N981 N592 buf
XBUFF1_200 N985 N592 buf
XBUFF1_207 N994 N595 buf
XBUFF1_209 N998 N595 buf
XBUFF1_219 N1010 N559 buf
XBUFF1_220 N1013 N559 buf
XBUFF1_221 N1016 N565 buf
XBUFF1_222 N1019 N565 buf
XBUFF1_223 N1022 N571 buf
XBUFF1_224 N1025 N571 buf
XBUFF1_225 N1028 N577 buf
XBUFF1_226 N1031 N577 buf
XBUFF1_227 N1034 N583 buf
XBUFF1_228 N1037 N583 buf
XBUFF1_229 N1040 N589 buf
XBUFF1_230 N1043 N589 buf
XBUFF1_231 N1046 N598 buf
XBUFF1_232 N1049 N598 buf
XBUFF1_265 N1164 N899 buf
XBUFF1_267 N1168 N903 buf
XBUFF1_307 N1252 N907 buf
XBUFF1_308 N1255 N907 buf
XBUFF1_309 N1258 N910 buf
XBUFF1_310 N1261 N910 buf
XBUFF1_359 N1416 N1264 buf
XBUFF1_360 N1419 N1264 buf
XBUFF1_437 N1588 N1522 buf
XBUFF1_443 N1600 N1517 buf
XBUFF1_444 N1603 N1517 buf
XBUFF1_445 N1606 N1522 buf
XBUFF1_446 N1609 N1522 buf
XBUFF1_447 N1612 N1514 buf
XBUFF1_448 N1615 N1514 buf
XBUFF1_449 N1620 N1557 buf
XBUFF1_450 N1623 N1554 buf
XBUFF1_455 N1640 N1561 buf
XBUFF1_456 N1643 N1561 buf
XBUFF1_457 N1647 N1546 buf
XBUFF1_458 N1651 N1546 buf
XBUFF1_459 N1658 N1554 buf
XBUFF1_460 N1661 N1557 buf
XBUFF1_461 N1664 N1557 buf
XBUFF1_474 N1697 N1588 buf
XBUFF1_475 N1701 N1588 buf
XBUFF1_484 N1714 N1620 buf
XBUFF1_485 N1717 N1620 buf
XBUFF1_492 N1731 N1623 buf
XBUFF1_493 N1734 N1623 buf
XBUFF1_531 N1818 N1742 buf
XBUFF1_553 N1866 N1798 buf
XBUFF1_554 N1869 N1802 buf
XBUFF1_555 N1872 N1802 buf
XBUFF1_568 N1902 N1830 buf
XBUFF1_580 N1927 N1858 buf
XBUFF1_581 N1930 N1858 buf
XBUFF1_588 N1944 N1879 buf
XBUFF1_590 N1950 N1889 buf
XBUFF1_591 N1953 N1889 buf
XBUFF1_592 N1958 N1879 buf
XBUFF1_630 N2033 N1980 buf
XBUFF1_646 N2071 N2027 buf
XBUFF1_652 N2089 N2042 buf
XBUFF1_657 N2148 N2062 buf
XBUFF1_658 N2151 N2062 buf
XBUFF1_659 N2196 N2078 buf
XBUFF1_660 N2199 N2078 buf
XBUFF1_661 N2202 N2081 buf
XBUFF1_662 N2205 N2081 buf
XBUFF1_691 N2260 N2237 buf
XBUFF1_697 N2286 N2266 buf
XBUFF1_698 N2297 N2266 buf
XBUFF1_699 N2315 N2272 buf
XBUFF1_700 N2326 N2272 buf
XNOT1_1 N190 N1 not
XNOT1_2 N194 N4 not
XNOT1_3 N197 N7 not
XNOT1_4 N201 N10 not
XNOT1_5 N206 N13 not
XNOT1_6 N209 N16 not
XNOT1_7 N212 N19 not
XNOT1_8 N216 N22 not
XNOT1_9 N220 N25 not
XNOT1_10 N225 N28 not
XNOT1_11 N229 N31 not
XNOT1_12 N232 N34 not
XNOT1_13 N235 N37 not
XNOT1_14 N239 N40 not
XNOT1_15 N243 N43 not
XNOT1_16 N247 N46 not
XNOT1_19 N253 N72 not
XNOT1_20 N256 N72 not
XNOT1_23 N263 N76 not
XNOT1_24 N266 N79 not
XNOT1_25 N269 N82 not
XNOT1_26 N272 N85 not
XNOT1_27 N275 N104 not
XNOT1_28 N276 N104 not
XNOT1_29 N277 N88 not
XNOT1_30 N280 N91 not
XNOT1_32 N290 N94 not
XNOT1_34 N300 N94 not
XNOT1_36 N306 N99 not
XNOT1_37 N313 N99 not
XNOT1_39 N319 N104 not
XNOT1_42 N338 N104 not
XNOT1_59 N534 N343 not
XNOT1_60 N535 N346 not
XNOT1_61 N536 N349 not
XNOT1_62 N537 N352 not
XNOT1_63 N538 N355 not
XNOT1_64 N539 N358 not
XNOT1_65 N540 N361 not
XNOT1_66 N541 N364 not
XNOT1_67 N542 N367 not
XNOT1_68 N543 N370 not
XNOT1_69 N544 N373 not
XNOT1_70 N545 N376 not
XNOT1_71 N546 N379 not
XNOT1_72 N547 N382 not
XNOT1_73 N548 N385 not
XNOT1_74 N549 N388 not
XNOT1_147 N886 N682 not
XNOT1_148 N887 N685 not
XNOT1_149 N888 N616 not
XNOT1_150 N889 N619 not
XNOT1_151 N890 N622 not
XNOT1_152 N891 N625 not
XNOT1_153 N892 N631 not
XNOT1_154 N893 N643 not
XNOT1_155 N894 N649 not
XNOT1_156 N895 N652 not
XNOT1_157 N896 N655 not
XNOT1_164 N913 N661 not
XNOT1_165 N914 N658 not
XNOT1_166 N915 N667 not
XNOT1_167 N916 N664 not
XNOT1_168 N917 N673 not
XNOT1_169 N918 N670 not
XNOT1_170 N919 N679 not
XNOT1_171 N920 N676 not
XNOT1_177 N938 N688 not
XNOT1_179 N942 N691 not
XNOT1_181 N946 N694 not
XNOT1_183 N950 N697 not
XNOT1_185 N954 N700 not
XNOT1_187 N958 N703 not
XNOT1_191 N968 N706 not
XNOT1_193 N972 N709 not
XNOT1_195 N976 N712 not
XNOT1_197 N980 N715 not
XNOT1_199 N984 N628 not
XNOT1_201 N988 N718 not
XNOT1_202 N989 N721 not
XNOT1_203 N990 N634 not
XNOT1_204 N991 N724 not
XNOT1_205 N992 N727 not
XNOT1_206 N993 N637 not
XNOT1_208 N997 N730 not
XNOT1_210 N1001 N733 not
XNOT1_211 N1002 N736 not
XNOT1_212 N1003 N739 not
XNOT1_213 N1004 N640 not
XNOT1_214 N1005 N742 not
XNOT1_215 N1006 N745 not
XNOT1_216 N1007 N646 not
XNOT1_217 N1008 N748 not
XNOT1_218 N1009 N751 not
XNOT1_249 N1148 N939 not
XNOT1_250 N1149 N935 not
XNOT1_252 N1151 N943 not
XNOT1_253 N1152 N947 not
XNOT1_254 N1153 N955 not
XNOT1_255 N1154 N951 not
XNOT1_256 N1155 N962 not
XNOT1_257 N1156 N969 not
XNOT1_258 N1157 N977 not
XNOT1_260 N1159 N985 not
XNOT1_262 N1161 N998 not
XNOT1_264 N1163 N899 not
XNOT1_266 N1167 N903 not
XNOT1_270 N1205 N1010 not
XNOT1_272 N1207 N1013 not
XNOT1_274 N1209 N1016 not
XNOT1_276 N1211 N1019 not
XNOT1_278 N1213 N1022 not
XNOT1_280 N1215 N1025 not
XNOT1_282 N1217 N1028 not
XNOT1_283 N1218 N959 not
XNOT1_284 N1219 N1031 not
XNOT1_285 N1220 N1034 not
XNOT1_287 N1222 N965 not
XNOT1_288 N1223 N1037 not
XNOT1_290 N1225 N1040 not
XNOT1_292 N1227 N973 not
XNOT1_293 N1228 N1043 not
XNOT1_295 N1230 N981 not
XNOT1_299 N1238 N1046 not
XNOT1_301 N1240 N994 not
XNOT1_302 N1241 N1049 not
XNOT1_311 N1264 N1150 not
XNOT1_323 N1319 N1158 not
XNOT1_327 N1334 N1162 not
XNOT1_330 N1346 N1249 not
XNOT1_331 N1348 N1255 not
XNOT1_332 N1349 N1252 not
XNOT1_333 N1350 N1261 not
XNOT1_334 N1351 N1258 not
XNOT1_346 N1386 N1232 not
XNOT1_348 N1388 N1235 not
XNOT1_352 N1396 N1243 not
XNOT1_354 N1398 N1246 not
XNOT1_356 N1409 N1319 not
XNOT1_358 N1413 N1334 not
XNOT1_365 N1440 N1344 not
XNOT1_367 N1444 N1355 not
XNOT1_369 N1446 N1352 not
XNOT1_371 N1448 N1358 not
XNOT1_373 N1452 N1361 not
XNOT1_375 N1454 N1367 not
XNOT1_377 N1456 N1364 not
XNOT1_379 N1458 N1373 not
XNOT1_381 N1460 N1379 not
XNOT1_382 N1461 N1383 not
XNOT1_384 N1463 N1393 not
XNOT1_386 N1468 N1370 not
XNOT1_388 N1470 N1376 not
XNOT1_391 N1475 N1390 not
XNOT1_399 N1490 N1419 not
XNOT1_400 N1491 N1416 not
XNOT1_407 N1499 N1440 not
XNOT1_411 N1510 N1464 not
XNOT1_420 N1528 N1472 not
XNOT1_422 N1530 N1478 not
XNOT1_423 N1531 N1481 not
XNOT1_424 N1532 N1484 not
XNOT1_428 N1546 N1513 not
XNOT1_429 N1554 N1521 not
XNOT1_430 N1557 N1526 not
XNOT1_431 N1561 N1520 not
XNOT1_434 N1569 N1510 not
XNOT1_435 N1571 N1527 not
XNOT1_436 N1576 N1529 not
XNOT1_438 N1591 N1534 not
XNOT1_439 N1593 N1537 not
XNOT1_441 N1595 N1540 not
XNOT1_451 N1635 N1571 not
XNOT1_454 N1639 N1576 not
XNOT1_463 N1672 N1596 not
XNOT1_464 N1675 N1600 not
XNOT1_465 N1677 N1603 not
XNOT1_467 N1679 N1606 not
XNOT1_469 N1681 N1609 not
XNOT1_470 N1682 N1612 not
XNOT1_471 N1683 N1615 not
XNOT1_477 N1707 N1643 not
XNOT1_479 N1709 N1647 not
XNOT1_481 N1711 N1651 not
XNOT1_487 N1721 N1658 not
XNOT1_489 N1727 N1661 not
XNOT1_490 N1728 N1640 not
XNOT1_491 N1730 N1664 not
XNOT1_495 N1741 N1685 not
XNOT1_502 N1761 N1697 not
XNOT1_504 N1763 N1701 not
XNOT1_506 N1768 N1717 not
XNOT1_509 N1773 N1723 not
XNOT1_512 N1783 N1731 not
XNOT1_514 N1785 N1714 not
XNOT1_515 N1786 N1734 not
XNOT1_521 N1796 N1751 not
XNOT1_525 N1807 N1748 not
XNOT1_533 N1822 N1777 not
XNOT1_535 N1824 N1774 not
XNOT1_538 N1827 N1788 not
XNOT1_548 N1856 N1815 not
XNOT1_549 N1857 N1818 not
XNOT1_551 N1864 N1812 not
XNOT1_560 N1883 N1841 not
XNOT1_564 N1895 N1838 not
XNOT1_567 N1898 N1850 not
XNOT1_569 N1910 N1878 not
XNOT1_571 N1912 N1884 not
XNOT1_573 N1915 N1866 not
XNOT1_575 N1920 N1872 not
XNOT1_577 N1922 N1869 not
XNOT1_578 N1923 N1875 not
XNOT1_584 N1937 N1898 not
XNOT1_585 N1938 N1902 not
XNOT1_589 N1947 N1913 not
XNOT1_597 N1976 N1930 not
XNOT1_599 N1978 N1927 not
XNOT1_602 N1985 N1933 not
XNOT1_603 N1987 N1936 not
XNOT1_604 N1999 N1944 not
XNOT1_606 N2002 N1947 not
XNOT1_609 N2005 N1953 not
XNOT1_611 N2007 N1950 not
XNOT1_614 N2012 N1979 not
XNOT1_615 N2013 N1958 not
XNOT1_617 N2015 N1961 not
XNOT1_619 N2018 N1965 not
XNOT1_620 N2019 N1968 not
XNOT1_622 N2021 N1987 not
XNOT1_629 N2030 N1980 not
XNOT1_638 N2047 N2026 not
XNOT1_641 N2060 N2038 not
XNOT1_644 N2067 N2041 not
XNOT1_645 N2068 N2027 not
XNOT1_647 N2076 N2052 not
XNOT1_648 N2077 N2055 not
XNOT1_651 N2086 N2042 not
XNOT1_664 N2215 N2151 not
XNOT1_666 N2217 N2148 not
XNOT1_668 N2223 N2199 not
XNOT1_670 N2225 N2196 not
XNOT1_672 N2227 N2205 not
XNOT1_674 N2229 N2202 not
XNOT1_687 N2250 N2236 not
XNOT1_688 N2253 N2240 not
XNOT1_689 N2256 N2244 not
XNOT1_690 N2257 N2237 not
XNOT1_692 N2263 N2241 not
XNOT1_694 N2269 N2245 not
XNOT1_751 N2670 N2558 not
XNOT1_753 N2672 N2561 not
XNOT1_755 N2674 N2564 not
XNOT1_757 N2676 N2567 not
XNOT1_759 N2683 N2570 not
XNOT1_761 N2689 N2573 not
XNOT1_763 N2691 N2576 not
XNOT1_770 N2725 N2639 not
XNOT1_772 N2727 N2642 not
XNOT1_774 N2729 N2645 not
XNOT1_776 N2731 N2648 not
XNOT1_778 N2733 N2651 not
XNOT1_781 N2736 N2655 not
XNOT1_783 N2738 N2658 not
XNOT1_785 N2740 N2661 not
XNOT1_787 N2742 N2664 not
XNOT1_825 N2808 N2773 not
XNOT1_827 N2810 N2776 not
XNOT1_844 N2857 N2812 not
XNOT1_845 N2858 N2815 not
XNOT1_846 N2859 N2818 not
XNOT1_847 N2860 N2821 not
XNOT1_848 N2861 N2824 not
XNOT1_849 N2862 N2829 not
XNOT1_857 N2872 N2843 not
XNOT1_859 N2874 N2846 not
XNOT1_877 N2896 N2883 not
.ENDS
