$ Spice netlist generated by v2lvs
$ v2013.3_28.19    Tue Sep 3 16:44:15 PDT 2013

.SUBCKT c34 P1_N1 P1_N2 P1_N3 P1_N6 P1_N7 P1_N22 P1_N23 P2_N1 P2_N2 P2_N3 P2_N6 P2_N7 P2_N22 P2_N23
XNAND2_1 P1_N10 P1_N1 P1_N3 nand
XNAND2_2 P1_N11 P1_N3 P1_N6 nand
XNAND2_3 P1_N16 P1_N2 P1_N11 nand
XNAND2_4 P1_N19 P1_N11 P1_N7 nand
XNAND2_5 P1_N22 P1_N10 P1_N16 nand
XNAND2_6 P1_N23 P1_N16 P1_N19 nand
XNAND2_7 P2_N10 P2_N1 P2_N3 nand
XNAND2_8 P2_N11 P2_N3 P2_N6 nand
XNAND2_9 P2_N16 P2_N2 P2_N11 nand
XNAND2_10 P2_N19 P2_N11 P2_N7 nand
XNAND2_11 P2_N22 P2_N10 P2_N16 nand
XNAND2_12 P2_N23 P2_N16 P2_N19 nand
.ENDS
