$ Spice netlist generated by v2lvs
$ v2013.3_28.19    Tue Sep 3 16:44:15 PDT 2013

.SUBCKT c432 N1 N4 N8 N11 N14 N17 N21 N24 N27 N30 N34 N37 N40 N43 N47 N50 N53
+ N56 N60 N63 N66 N69 N73 N76 N79 N82 N86 N89 N92 N95 N99 N102 N105 N108 N112
+ N115 N223 N329 N370 N421 N430 N431 N432
XAND9_46 N199 N154 N159 N162 N165 N168 N171 N174 N177 N180 and
XAND9_86 N296 N260 N264 N267 N270 N273 N276 N279 N282 N285 and
XAND9_126 N357 N348 N349 N350 N351 N352 N353 N354 N355 N356 and
XAND8_148 N416 N381 N386 N393 N399 N404 N407 N411 N414 and
XNAND2_19 N154 N118 N4 nand
XNAND2_22 N159 N122 N17 nand
XNAND2_23 N162 N126 N30 nand
XNAND2_24 N165 N130 N43 nand
XNAND2_25 N168 N134 N56 nand
XNAND2_26 N171 N138 N69 nand
XNAND2_27 N174 N142 N82 nand
XNAND2_28 N177 N146 N95 nand
XNAND2_29 N180 N150 N108 nand
XNAND2_56 N242 N1 N213 nand
XNAND2_58 N246 N213 N11 nand
XNAND2_60 N250 N213 N24 nand
XNAND2_62 N254 N213 N37 nand
XNAND2_63 N255 N213 N50 nand
XNAND2_64 N256 N213 N63 nand
XNAND2_65 N257 N213 N76 nand
XNAND2_66 N258 N213 N89 nand
XNAND2_67 N259 N213 N102 nand
XNAND2_68 N260 N224 N157 nand
XNAND2_69 N263 N224 N158 nand
XNAND2_70 N264 N227 N183 nand
XNAND2_71 N267 N230 N185 nand
XNAND2_72 N270 N233 N187 nand
XNAND2_73 N273 N236 N189 nand
XNAND2_74 N276 N239 N191 nand
XNAND2_75 N279 N243 N193 nand
XNAND2_76 N282 N247 N195 nand
XNAND2_77 N285 N251 N197 nand
XNAND2_78 N288 N227 N184 nand
XNAND2_79 N289 N230 N186 nand
XNAND2_80 N290 N233 N188 nand
XNAND2_81 N291 N236 N190 nand
XNAND2_82 N292 N239 N192 nand
XNAND2_83 N293 N243 N194 nand
XNAND2_84 N294 N247 N196 nand
XNAND2_85 N295 N251 N198 nand
XNAND2_103 N334 N8 N319 nand
XNAND2_105 N336 N319 N21 nand
XNAND2_107 N338 N319 N34 nand
XNAND2_109 N340 N319 N47 nand
XNAND2_111 N342 N319 N60 nand
XNAND2_113 N344 N319 N73 nand
XNAND2_114 N345 N319 N86 nand
XNAND2_115 N346 N319 N99 nand
XNAND2_116 N347 N319 N112 nand
XNAND2_117 N348 N330 N300 nand
XNAND2_118 N349 N331 N301 nand
XNAND2_119 N350 N332 N302 nand
XNAND2_120 N351 N333 N303 nand
XNAND2_121 N352 N335 N304 nand
XNAND2_122 N353 N337 N305 nand
XNAND2_123 N354 N339 N306 nand
XNAND2_124 N355 N341 N307 nand
XNAND2_125 N356 N343 N308 nand
XNAND2_129 N371 N14 N360 nand
XNAND2_130 N372 N360 N27 nand
XNAND2_131 N373 N360 N40 nand
XNAND2_132 N374 N360 N53 nand
XNAND2_133 N375 N360 N66 nand
XNAND2_134 N376 N360 N79 nand
XNAND2_135 N377 N360 N92 nand
XNAND2_136 N378 N360 N105 nand
XNAND2_137 N379 N360 N115 nand
XNAND4_138 N380 N4 N242 N334 N371 nand
XNAND4_139 N381 N246 N336 N372 N17 nand
XNAND4_140 N386 N250 N338 N373 N30 nand
XNAND4_141 N393 N254 N340 N374 N43 nand
XNAND4_142 N399 N255 N342 N375 N56 nand
XNAND4_143 N404 N256 N344 N376 N69 nand
XNAND4_144 N407 N257 N345 N377 N82 nand
XNAND4_145 N411 N258 N346 N378 N95 nand
XNAND4_146 N414 N259 N347 N379 N108 nand
XNAND2_154 N422 N386 N417 nand
XNAND4_155 N425 N386 N393 N418 N399 nand
XNAND3_156 N428 N399 N393 N419 nand
XNAND4_157 N429 N386 N393 N407 N420 nand
XNAND4_158 N430 N381 N386 N422 N399 nand
XNAND4_159 N431 N381 N386 N425 N428 nand
XNAND4_160 N432 N381 N422 N425 N429 nand
XNOR2_20 N157 N8 N119 nor
XNOR2_21 N158 N14 N119 nor
XNOR2_30 N183 N21 N123 nor
XNOR2_31 N184 N27 N123 nor
XNOR2_32 N185 N34 N127 nor
XNOR2_33 N186 N40 N127 nor
XNOR2_34 N187 N47 N131 nor
XNOR2_35 N188 N53 N131 nor
XNOR2_36 N189 N60 N135 nor
XNOR2_37 N190 N66 N135 nor
XNOR2_38 N191 N73 N139 nor
XNOR2_39 N192 N79 N139 nor
XNOR2_40 N193 N86 N143 nor
XNOR2_41 N194 N92 N143 nor
XNOR2_42 N195 N99 N147 nor
XNOR2_43 N196 N105 N147 nor
XNOR2_44 N197 N112 N151 nor
XNOR2_45 N198 N115 N151 nor
XNOR2_153 N421 N415 N416 nor
XXOR2_50 N224 N203 N154 xor
XXOR2_51 N227 N203 N159 xor
XXOR2_52 N230 N203 N162 xor
XXOR2_53 N233 N203 N165 xor
XXOR2_54 N236 N203 N168 xor
XXOR2_55 N239 N203 N171 xor
XXOR2_57 N243 N203 N174 xor
XXOR2_59 N247 N203 N177 xor
XXOR2_61 N251 N203 N180 xor
XXOR2_99 N330 N309 N260 xor
XXOR2_100 N331 N309 N264 xor
XXOR2_101 N332 N309 N267 xor
XXOR2_102 N333 N309 N270 xor
XXOR2_104 N335 N309 N273 xor
XXOR2_106 N337 N309 N276 xor
XXOR2_108 N339 N309 N279 xor
XXOR2_110 N341 N309 N282 xor
XXOR2_112 N343 N309 N285 xor
XNOT1_1 N118 N1 not
XNOT1_2 N119 N4 not
XNOT1_3 N122 N11 not
XNOT1_4 N123 N17 not
XNOT1_5 N126 N24 not
XNOT1_6 N127 N30 not
XNOT1_7 N130 N37 not
XNOT1_8 N131 N43 not
XNOT1_9 N134 N50 not
XNOT1_10 N135 N56 not
XNOT1_11 N138 N63 not
XNOT1_12 N139 N69 not
XNOT1_13 N142 N76 not
XNOT1_14 N143 N82 not
XNOT1_15 N146 N89 not
XNOT1_16 N147 N95 not
XNOT1_17 N150 N102 not
XNOT1_18 N151 N108 not
XNOT1_47 N203 N199 not
XNOT1_48 N213 N199 not
XNOT1_49 N223 N199 not
XNOT1_87 N300 N263 not
XNOT1_88 N301 N288 not
XNOT1_89 N302 N289 not
XNOT1_90 N303 N290 not
XNOT1_91 N304 N291 not
XNOT1_92 N305 N292 not
XNOT1_93 N306 N293 not
XNOT1_94 N307 N294 not
XNOT1_95 N308 N295 not
XNOT1_96 N309 N296 not
XNOT1_97 N319 N296 not
XNOT1_98 N329 N296 not
XNOT1_127 N360 N357 not
XNOT1_128 N370 N357 not
XNOT1_147 N415 N380 not
XNOT1_149 N417 N393 not
XNOT1_150 N418 N404 not
XNOT1_151 N419 N407 not
XNOT1_152 N420 N411 not
.ENDS
