$ Spice netlist generated by v2lvs
$ v2013.3_28.19    Tue Sep 3 16:44:15 PDT 2013

.SUBCKT c499 N1 N5 N9 N13 N17 N21 N25 N29 N33 N37 N41 N45 N49 N53 N57 N61 N65
+ N69 N73 N77 N81 N85 N89 N93 N97 N101 N105 N109 N113 N117 N121 N125 N129 N130
+ N131 N132 N133 N134 N135 N136 N137 N724 N725 N726 N727 N728 N729 N730 N731
+ N732 N733 N734 N735 N736 N737 N738 N739 N740 N741 N742 N743 N744 N745 N746
+ N747 N748 N749 N750 N751 N752 N753 N754 N755
XAND2_17 N266 N129 N137 and
XAND2_18 N267 N130 N137 and
XAND2_19 N268 N131 N137 and
XAND2_20 N269 N132 N137 and
XAND2_21 N270 N133 N137 and
XAND2_22 N271 N134 N137 and
XAND2_23 N272 N135 N137 and
XAND2_24 N273 N136 N137 and
XAND4_121 N594 N554 N555 N556 N393 and
XAND4_122 N595 N557 N558 N380 N559 and
XAND4_123 N596 N560 N367 N561 N562 and
XAND4_124 N597 N354 N563 N564 N565 and
XAND4_125 N598 N574 N575 N576 N445 and
XAND4_126 N599 N577 N578 N432 N579 and
XAND4_127 N600 N580 N419 N581 N582 and
XAND4_128 N601 N406 N583 N584 N585 and
XAND5_131 N620 N406 N566 N432 N567 N602 and
XAND5_132 N625 N406 N568 N569 N445 N602 and
XAND5_133 N630 N570 N419 N432 N571 N602 and
XAND5_134 N635 N572 N419 N573 N445 N602 and
XAND5_135 N640 N354 N586 N380 N587 N607 and
XAND5_136 N645 N354 N588 N589 N393 N607 and
XAND5_137 N650 N590 N367 N380 N591 N607 and
XAND5_138 N655 N592 N367 N593 N393 N607 and
XAND2_139 N692 N354 N620 and
XAND2_140 N693 N367 N620 and
XAND2_141 N694 N380 N620 and
XAND2_142 N695 N393 N620 and
XAND2_143 N696 N354 N625 and
XAND2_144 N697 N367 N625 and
XAND2_145 N698 N380 N625 and
XAND2_146 N699 N393 N625 and
XAND2_147 N700 N354 N630 and
XAND2_148 N701 N367 N630 and
XAND2_149 N702 N380 N630 and
XAND2_150 N703 N393 N630 and
XAND2_151 N704 N354 N635 and
XAND2_152 N705 N367 N635 and
XAND2_153 N706 N380 N635 and
XAND2_154 N707 N393 N635 and
XAND2_155 N708 N406 N640 and
XAND2_156 N709 N419 N640 and
XAND2_157 N710 N432 N640 and
XAND2_158 N711 N445 N640 and
XAND2_159 N712 N406 N645 and
XAND2_160 N713 N419 N645 and
XAND2_161 N714 N432 N645 and
XAND2_162 N715 N445 N645 and
XAND2_163 N716 N406 N650 and
XAND2_164 N717 N419 N650 and
XAND2_165 N718 N432 N650 and
XAND2_166 N719 N445 N650 and
XAND2_167 N720 N406 N655 and
XAND2_168 N721 N419 N655 and
XAND2_169 N722 N432 N655 and
XAND2_170 N723 N445 N655 and
XOR4_129 N602 N594 N595 N596 N597 or
XOR4_130 N607 N598 N599 N600 N601 or
XXOR2_1 N250 N1 N5 xor
XXOR2_2 N251 N9 N13 xor
XXOR2_3 N252 N17 N21 xor
XXOR2_4 N253 N25 N29 xor
XXOR2_5 N254 N33 N37 xor
XXOR2_6 N255 N41 N45 xor
XXOR2_7 N256 N49 N53 xor
XXOR2_8 N257 N57 N61 xor
XXOR2_9 N258 N65 N69 xor
XXOR2_10 N259 N73 N77 xor
XXOR2_11 N260 N81 N85 xor
XXOR2_12 N261 N89 N93 xor
XXOR2_13 N262 N97 N101 xor
XXOR2_14 N263 N105 N109 xor
XXOR2_15 N264 N113 N117 xor
XXOR2_16 N265 N121 N125 xor
XXOR2_25 N274 N1 N17 xor
XXOR2_26 N275 N33 N49 xor
XXOR2_27 N276 N5 N21 xor
XXOR2_28 N277 N37 N53 xor
XXOR2_29 N278 N9 N25 xor
XXOR2_30 N279 N41 N57 xor
XXOR2_31 N280 N13 N29 xor
XXOR2_32 N281 N45 N61 xor
XXOR2_33 N282 N65 N81 xor
XXOR2_34 N283 N97 N113 xor
XXOR2_35 N284 N69 N85 xor
XXOR2_36 N285 N101 N117 xor
XXOR2_37 N286 N73 N89 xor
XXOR2_38 N287 N105 N121 xor
XXOR2_39 N288 N77 N93 xor
XXOR2_40 N289 N109 N125 xor
XXOR2_41 N290 N250 N251 xor
XXOR2_42 N293 N252 N253 xor
XXOR2_43 N296 N254 N255 xor
XXOR2_44 N299 N256 N257 xor
XXOR2_45 N302 N258 N259 xor
XXOR2_46 N305 N260 N261 xor
XXOR2_47 N308 N262 N263 xor
XXOR2_48 N311 N264 N265 xor
XXOR2_49 N314 N274 N275 xor
XXOR2_50 N315 N276 N277 xor
XXOR2_51 N316 N278 N279 xor
XXOR2_52 N317 N280 N281 xor
XXOR2_53 N318 N282 N283 xor
XXOR2_54 N319 N284 N285 xor
XXOR2_55 N320 N286 N287 xor
XXOR2_56 N321 N288 N289 xor
XXOR2_57 N338 N290 N293 xor
XXOR2_58 N339 N296 N299 xor
XXOR2_59 N340 N290 N296 xor
XXOR2_60 N341 N293 N299 xor
XXOR2_61 N342 N302 N305 xor
XXOR2_62 N343 N308 N311 xor
XXOR2_63 N344 N302 N308 xor
XXOR2_64 N345 N305 N311 xor
XXOR2_65 N346 N266 N342 xor
XXOR2_66 N347 N267 N343 xor
XXOR2_67 N348 N268 N344 xor
XXOR2_68 N349 N269 N345 xor
XXOR2_69 N350 N270 N338 xor
XXOR2_70 N351 N271 N339 xor
XXOR2_71 N352 N272 N340 xor
XXOR2_72 N353 N273 N341 xor
XXOR2_73 N354 N314 N346 xor
XXOR2_74 N367 N315 N347 xor
XXOR2_75 N380 N316 N348 xor
XXOR2_76 N393 N317 N349 xor
XXOR2_77 N406 N318 N350 xor
XXOR2_78 N419 N319 N351 xor
XXOR2_79 N432 N320 N352 xor
XXOR2_80 N445 N321 N353 xor
XXOR2_171 N724 N1 N692 xor
XXOR2_172 N725 N5 N693 xor
XXOR2_173 N726 N9 N694 xor
XXOR2_174 N727 N13 N695 xor
XXOR2_175 N728 N17 N696 xor
XXOR2_176 N729 N21 N697 xor
XXOR2_177 N730 N25 N698 xor
XXOR2_178 N731 N29 N699 xor
XXOR2_179 N732 N33 N700 xor
XXOR2_180 N733 N37 N701 xor
XXOR2_181 N734 N41 N702 xor
XXOR2_182 N735 N45 N703 xor
XXOR2_183 N736 N49 N704 xor
XXOR2_184 N737 N53 N705 xor
XXOR2_185 N738 N57 N706 xor
XXOR2_186 N739 N61 N707 xor
XXOR2_187 N740 N65 N708 xor
XXOR2_188 N741 N69 N709 xor
XXOR2_189 N742 N73 N710 xor
XXOR2_190 N743 N77 N711 xor
XXOR2_191 N744 N81 N712 xor
XXOR2_192 N745 N85 N713 xor
XXOR2_193 N746 N89 N714 xor
XXOR2_194 N747 N93 N715 xor
XXOR2_195 N748 N97 N716 xor
XXOR2_196 N749 N101 N717 xor
XXOR2_197 N750 N105 N718 xor
XXOR2_198 N751 N109 N719 xor
XXOR2_199 N752 N113 N720 xor
XXOR2_200 N753 N117 N721 xor
XXOR2_201 N754 N121 N722 xor
XXOR2_202 N755 N125 N723 xor
XNOT1_81 N554 N354 not
XNOT1_82 N555 N367 not
XNOT1_83 N556 N380 not
XNOT1_84 N557 N354 not
XNOT1_85 N558 N367 not
XNOT1_86 N559 N393 not
XNOT1_87 N560 N354 not
XNOT1_88 N561 N380 not
XNOT1_89 N562 N393 not
XNOT1_90 N563 N367 not
XNOT1_91 N564 N380 not
XNOT1_92 N565 N393 not
XNOT1_93 N566 N419 not
XNOT1_94 N567 N445 not
XNOT1_95 N568 N419 not
XNOT1_96 N569 N432 not
XNOT1_97 N570 N406 not
XNOT1_98 N571 N445 not
XNOT1_99 N572 N406 not
XNOT1_100 N573 N432 not
XNOT1_101 N574 N406 not
XNOT1_102 N575 N419 not
XNOT1_103 N576 N432 not
XNOT1_104 N577 N406 not
XNOT1_105 N578 N419 not
XNOT1_106 N579 N445 not
XNOT1_107 N580 N406 not
XNOT1_108 N581 N432 not
XNOT1_109 N582 N445 not
XNOT1_110 N583 N419 not
XNOT1_111 N584 N432 not
XNOT1_112 N585 N445 not
XNOT1_113 N586 N367 not
XNOT1_114 N587 N393 not
XNOT1_115 N588 N367 not
XNOT1_116 N589 N380 not
XNOT1_117 N590 N354 not
XNOT1_118 N591 N393 not
XNOT1_119 N592 N354 not
XNOT1_120 N593 N380 not
.ENDS
