$ Spice netlist generated by v2lvs
$ v2013.3_28.19    Tue Sep 3 16:44:15 PDT 2013

.SUBCKT c7 N1 N2 N3 N4 N5 N6 N7 N8 N20 N21 N22 N23
XNAND2_1 N9  N1  N2  nand
XNAND2_2 N10 N3  N4  nand
XNAND2_3 N11 N5  N6  nand
XNAND2_4 N12 N7  N8  nand
XNAND2_5 N20 N9  N10 nand
XNAND2_6 N21 N11 N12 nand
XNAND2_7 N22 N9  N11 nand
XNAND2_8 N23 N10 N12 nand
.ENDS
